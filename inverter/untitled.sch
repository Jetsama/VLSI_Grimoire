v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/lab_pin.sym} -130 -230 0 0 {name=p1 sig_type=std_logic lab=xxx}
