v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 4 60 -60 250 70 {}
A 12 95 5 15.8113883008419 71.56505117707799 360 {}
A 12 225 5 15.8113883008419 198.434948822922 360 {}
A 12 165 105 65.19202405202648 57.52880770915151 64.94238458169698 {}
N 70 -40 120 -10 {}
N 180 -10 230 -30 {}
